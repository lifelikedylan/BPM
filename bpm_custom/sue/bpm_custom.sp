* FILE: bpm_custom.sp

* SPICE netlist for "bpm_custom" generated by MMI_SUE5.6.37 on Fri Dec
*+ 07 03:55:33 CST 2018.

.SUBCKT mux21 In_0 In_1 Out Sel Sel_bar
M_1 Out Sel In_1 gnd n W='3*1u' L='0.6*1u'
M_2 Out Sel_bar In_1 vdd p W='3*1u' L='0.6*1u'
M_3 Out Sel_bar In_0 gnd n W='3*1u' L='0.6*1u'
M_4 Out Sel In_0 vdd p W='3*1u' L='0.6*1u'
.ENDS	$ mux21

.SUBCKT inv IN OUT
Mp0 OUT IN Vdd vdd p W='6*1u' L='0.6*1u'
Mn0 OUT IN Gnd gnd n W='3*1u' L='0.6*1u'
.ENDS	$ inv

.SUBCKT FA a b c cout sum
M_1 net_10 net_2 net_9 gnd n W='3*1u' L='0.6*1u'
M_2 net_9 a gnd gnd n W='3*1u' L='0.6*1u'
M_3 net_9 b gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_9 c gnd gnd n W='3*1u' L='0.6*1u'
M_5 net_10 c net_12 gnd n W='3*1u' L='0.6*1u'
M_6 net_12 b net_8 gnd n W='3*1u' L='0.6*1u'
M_7 net_8 a gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_2 c net_5 gnd n W='3*1u' L='0.6*1u'
M_9 net_5 a gnd gnd n W='3*1u' L='0.6*1u'
M_10 net_5 b gnd gnd n W='3*1u' L='0.6*1u'
M_11 net_2 b net_4 gnd n W='3*1u' L='0.6*1u'
M_12 net_4 a gnd gnd n W='3*1u' L='0.6*1u'
M_13 net_11 a vdd vdd p W='6*1u' L='0.6*1u'
M_14 net_11 b vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_11 c vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_10 net_2 net_11 vdd p W='6*1u' L='0.6*1u'
M_17 net_1 b net_3 vdd p W='6*1u' L='0.6*1u'
M_18 net_10 c net_1 vdd p W='6*1u' L='0.6*1u'
M_19 net_3 a vdd vdd p W='6*1u' L='0.6*1u'
M_20 net_6 a vdd vdd p W='6*1u' L='0.6*1u'
M_21 net_6 b vdd vdd p W='6*1u' L='0.6*1u'
M_22 net_2 c net_6 vdd p W='6*1u' L='0.6*1u'
M_23 net_2 b net_7 vdd p W='6*1u' L='0.6*1u'
M_24 net_7 a vdd vdd p W='6*1u' L='0.6*1u'
Xinv net_2 cout inv
Xinv_1 net_10 sum inv
.ENDS	$ FA

.SUBCKT nand A B Y
M_1 net_1 A gnd gnd n W='6*1u' L='0.6*1u'
M_2 Y B net_1 gnd n W='6*1u' L='0.6*1u'
M_3 Y A vdd vdd p W='6*1u' L='0.6*1u'
M_4 Y B vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ nand

.SUBCKT andZ A B Z Z_b
Xnand A B Z_b nand
M_1 Z Z_b net_1 gnd n W='3*1u' L='0.6*1u'
M_2 net_1 Z_b gnd gnd n W='3*1u' L='0.6*1u'
M_3 net_2 Z_b vdd vdd p W='6*1u' L='0.6*1u'
M_4 Z Z_b net_2 vdd p W='6*1u' L='0.6*1u'
.ENDS	$ andZ

.SUBCKT dffposZ Clk Clk_b D Q
M_1 net_13 net_1 gnd gnd n W='3*1u' L='0.6*1u'
M_2 net_4 Clk net_13 gnd n W='3*1u' L='0.6*1u'
M_3 net_6 net_1 gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_3 Clk net_6 gnd n W='3*1u' L='0.6*1u'
M_5 net_3 Clk_b net_12 vdd p W='6*1u' L='0.6*1u'
M_6 net_12 net_1 vdd vdd p W='6*1u' L='0.6*1u'
M_7 net_2 D gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_4 Clk_b net_2 gnd n W='3*1u' L='0.6*1u'
M_9 net_4 Clk net_10 vdd p W='6*1u' L='0.6*1u'
M_10 net_10 D vdd vdd p W='6*1u' L='0.6*1u'
M_11 net_11 Q gnd gnd n W='3*1u' L='0.6*1u'
M_12 net_3 Clk_b net_11 gnd n W='3*1u' L='0.6*1u'
M_13 net_3 Clk net_5 vdd p W='6*1u' L='0.6*1u'
M_14 net_5 Q vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_9 net_1 vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_4 Clk_b net_9 vdd p W='6*1u' L='0.6*1u'
M_17 net_1 net_4 gnd gnd n W='3*1u' L='0.6*1u'
M_18 net_1 net_4 vdd vdd p W='6*1u' L='0.6*1u'
M_19 net_7 net_3 vdd vdd p W='6*1u' L='0.6*1u'
M_20 Q net_3 net_7 vdd p W='6*1u' L='0.6*1u'
M_21 Q net_3 net_8 gnd n W='3*1u' L='0.6*1u'
M_22 net_8 net_3 gnd gnd n W='3*1u' L='0.6*1u'
.ENDS	$ dffposZ

.SUBCKT bit1a Cin Cout Init Out add_out clk en fa_in muxA_in muxB_in
+ reg_in
Xmux21 reg_in gnd net_3 Init net_4 mux21
XFA net_3 fa_in Cin Cout add_out FA
Xinv Init net_4 inv
Xmux21_1 muxA_in muxB_in net_1 Init net_4 mux21
XandZ clk en net_2 net_5 andZ
XdffposZ net_2 net_5 net_1 Out dffposZ
.ENDS	$ bit1a

.SUBCKT bit1b Init Out clk en mcand mplier muxA_in muxA_out muxB_in
+ muxB_out q0 reg_in
Xmux21 gnd mcand muxA_out q0 net_5 mux21
Xinv Init net_2 inv
Xmux21_1 muxA_in muxB_in net_1 Init net_2 mux21
Xmux21_2 reg_in mplier muxB_out Init net_2 mux21
Xinv_1 q0 net_5 inv
XandZ clk en net_3 net_4 andZ
XdffposZ net_3 net_4 net_1 Out dffposZ
.ENDS	$ bit1b

.SUBCKT bpm_custom clk en init mcand[0] mcand[1] mcand[2] mcand[3]
+ mcand[4] mcand[5] mcand[6] mcand[7] mplier[0] mplier[1] mplier[2]
+ mplier[3] mplier[4] mplier[5] mplier[6] mplier[7] q[0] q[1] q[2] q[3]
+ q[4] q[5] q[6] q[7] q[8] q[9] q[10] q[11] q[12] q[13] q[14] q[15]
Xbit1a net_1 cout init q[15] fa[7] clk en ai[7] cout gnd q[15] bit1a
Xbit1a_1 net_6 net_1 init q[14] fa[6] clk en ai[6] fa[7] gnd q[14] bit1a
Xbit1a_2 net_2 net_6 init q[13] fa[5] clk en ai[5] fa[6] gnd q[13] bit1a
Xbit1a_3 net_5 net_2 init q[12] fa[4] clk en ai[4] fa[5] gnd q[12] bit1a
Xbit1b init q[7] clk en mcand[7] mplier[7] fa[0] ai[7] ao[7] ao[7] q[0]
+ q[7] bit1b
Xbit1b_1 init q[6] clk en mcand[6] mplier[6] ao[7] ai[6] ao[6] ao[6]
+ q[0] q[6] bit1b
Xbit1b_2 init q[5] clk en mcand[5] mplier[5] ao[6] ai[5] ao[5] ao[5]
+ q[0] q[5] bit1b
Xbit1b_3 init q[4] clk en mcand[4] mplier[4] ao[5] ai[4] ao[4] ao[4]
+ q[0] q[4] bit1b
Xbit1a_4 net_7 net_5 init q[11] fa[3] clk en ai[3] fa[4] gnd q[11] bit1a
Xbit1a_5 net_3 net_7 init q[10] fa[2] clk en ai[2] fa[3] gnd q[10] bit1a
Xbit1a_6 net_4 net_3 init q[9] fa[1] clk en ai[1] fa[2] gnd q[9] bit1a
Xbit1a_7 gnd net_4 init q[8] fa[0] clk en ai[0] fa[1] gnd q[8] bit1a
Xbit1b_4 init q[3] clk en mcand[3] mplier[3] ao[4] ai[3] ao[3] ao[3]
+ q[0] q[3] bit1b
Xbit1b_5 init q[2] clk en mcand[2] mplier[2] ao[3] ai[2] ao[2] ao[2]
+ q[0] q[2] bit1b
Xbit1b_6 init q[1] clk en mcand[1] mplier[1] ao[2] ai[1] ao[1] ao[1]
+ q[0] q[1] bit1b
Xbit1b_7 init q[0] clk en mcand[0] mplier[0] ao[1] ai[0] ao[0] ao[0]
+ q[0] q[0] bit1b
.ENDS	$ bpm_custom

.GLOBAL gnd vdd
