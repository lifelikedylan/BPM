* FILE: dffpos.sp

* SPICE netlist for "dffpos" generated by MMI_SUE5.6.37 on Mon Nov 26
*+ 16:16:32 CST 2018.

.SUBCKT dffpos Clk_b D Q
M_1 net_9 net_3 gnd gnd n W='3*1u' L='0.6*1u'
M_2 net_4 Clk net_9 gnd n W='3*1u' L='0.6*1u'
M_3 net_8 net_3 gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_2 Clk net_8 gnd n W='3*1u' L='0.6*1u'
M_5 net_2 Clk_b net_10 vdd p W='6*1u' L='0.6*1u'
M_6 net_10 net_3 vdd vdd p W='6*1u' L='0.6*1u'
M_7 net_1 D gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_4 Clk_b net_1 gnd n W='3*1u' L='0.6*1u'
M_9 net_4 Clk net_5 vdd p W='6*1u' L='0.6*1u'
M_10 net_5 D vdd vdd p W='6*1u' L='0.6*1u'
M_11 net_6 Q gnd gnd n W='3*1u' L='0.6*1u'
M_12 net_2 Clk_b net_6 gnd n W='3*1u' L='0.6*1u'
M_13 net_2 Clk net_12 vdd p W='6*1u' L='0.6*1u'
M_14 net_12 Q vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_14 net_3 vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_4 Clk_b net_14 vdd p W='6*1u' L='0.6*1u'
M_17 net_3 net_4 gnd gnd n W='3*1u' L='0.6*1u'
M_18 net_3 net_4 vdd vdd p W='6*1u' L='0.6*1u'
M_19 Q net_2 net_7 gnd n W='3*1u' L='0.6*1u'
M_20 net_7 net_2 gnd gnd n W='3*1u' L='0.6*1u'
M_21 net_11 net_2 vdd vdd p W='6*1u' L='0.6*1u'
M_22 Q net_2 net_11 vdd p W='6*1u' L='0.6*1u'
M_23 net_13 Clk_b gnd gnd n W='3*1u' L='0.6*1u'
M_24 Clk Clk_b net_13 gnd n W='3*1u' L='0.6*1u'
M_25 net_15 Clk_b vdd vdd p W='6*1u' L='0.6*1u'
M_26 Clk Clk_b net_15 vdd p W='6*1u' L='0.6*1u'
.ENDS	$ dffpos

.GLOBAL gnd vdd
