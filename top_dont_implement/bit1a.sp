* FILE: bit1a.sp

* SPICE netlist for "bit1a" generated by MMI_SUE5.6.37 on Mon Nov 26
*+ 18:16:10 CST 2018.

.SUBCKT mux21 In_0 In_1 Out Sel Sel_bar
M_1 Out Sel In_1 gnd n W='3*1u' L='0.6*1u'
M_2 Out Sel_bar In_1 vdd p W='3*1u' L='0.6*1u'
M_3 Out Sel_bar In_0 gnd n W='3*1u' L='0.6*1u'
M_4 Out Sel In_0 vdd p W='3*1u' L='0.6*1u'
.ENDS	$ mux21

.SUBCKT inv IN OUT
Mp0 OUT IN Vdd vdd p W='6*1u' L='0.6*1u'
Mn0 OUT IN Gnd gnd n W='3*1u' L='0.6*1u'
.ENDS	$ inv

.SUBCKT FA a b c cout sum
M_1 net_10 net_2 net_9 gnd n W='3*1u' L='0.6*1u'
M_2 net_9 a gnd gnd n W='3*1u' L='0.6*1u'
M_3 net_9 b gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_9 c gnd gnd n W='3*1u' L='0.6*1u'
M_5 net_10 c net_12 gnd n W='3*1u' L='0.6*1u'
M_6 net_12 b net_8 gnd n W='3*1u' L='0.6*1u'
M_7 net_8 a gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_2 c net_5 gnd n W='3*1u' L='0.6*1u'
M_9 net_5 a gnd gnd n W='3*1u' L='0.6*1u'
M_10 net_5 b gnd gnd n W='3*1u' L='0.6*1u'
M_11 net_2 b net_4 gnd n W='3*1u' L='0.6*1u'
M_12 net_4 a gnd gnd n W='3*1u' L='0.6*1u'
M_13 net_11 a vdd vdd p W='6*1u' L='0.6*1u'
M_14 net_11 b vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_11 c vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_10 net_2 net_11 vdd p W='6*1u' L='0.6*1u'
M_17 net_1 b net_3 vdd p W='6*1u' L='0.6*1u'
M_18 net_10 c net_1 vdd p W='6*1u' L='0.6*1u'
M_19 net_3 a vdd vdd p W='6*1u' L='0.6*1u'
M_20 net_6 a vdd vdd p W='6*1u' L='0.6*1u'
M_21 net_6 b vdd vdd p W='6*1u' L='0.6*1u'
M_22 net_2 c net_6 vdd p W='6*1u' L='0.6*1u'
M_23 net_2 b net_7 vdd p W='6*1u' L='0.6*1u'
M_24 net_7 a vdd vdd p W='6*1u' L='0.6*1u'
Xinv net_2 cout inv
Xinv_1 net_10 sum inv
.ENDS	$ FA

.SUBCKT dffpos Clk D Q
M_1 net_10 net_1 gnd gnd n W='3*1u' L='0.6*1u'
M_2 net_4 Clk net_10 gnd n W='3*1u' L='0.6*1u'
M_3 net_5 net_1 gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_3 Clk net_5 gnd n W='3*1u' L='0.6*1u'
M_5 net_3 Clk_b net_9 vdd p W='6*1u' L='0.6*1u'
M_6 net_9 net_1 vdd vdd p W='6*1u' L='0.6*1u'
M_7 net_2 D gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_4 Clk_b net_2 gnd n W='3*1u' L='0.6*1u'
M_9 net_4 Clk net_8 vdd p W='6*1u' L='0.6*1u'
M_10 net_8 D vdd vdd p W='6*1u' L='0.6*1u'
M_11 net_11 Q gnd gnd n W='3*1u' L='0.6*1u'
M_12 net_3 Clk_b net_11 gnd n W='3*1u' L='0.6*1u'
M_13 net_3 Clk net_7 vdd p W='6*1u' L='0.6*1u'
M_14 net_7 Q vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_6 net_1 vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_4 Clk_b net_6 vdd p W='6*1u' L='0.6*1u'
M_17 net_1 net_4 gnd gnd n W='3*1u' L='0.6*1u'
M_18 net_1 net_4 vdd vdd p W='6*1u' L='0.6*1u'
M_19 Clk_b Clk gnd gnd n W='6*1u' L='0.6*1u'
M_20 Clk_b Clk vdd vdd p W='12*1u' L='0.6*1u'
M_21 Q net_3 gnd gnd n W='6*1u' L='0.6*1u'
M_22 Q net_3 vdd vdd p W='12*1u' L='0.6*1u'
.ENDS	$ dffpos

.SUBCKT nand A B Y
M_1 net_1 A gnd gnd n W='6*1u' L='0.6*1u'
M_2 Y B net_1 gnd n W='6*1u' L='0.6*1u'
M_3 Y A vdd vdd p W='6*1u' L='0.6*1u'
M_4 Y B vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ nand

.SUBCKT and A B Z
Xnand A B net_1 nand
Xinv net_1 Z inv
.ENDS	$ and

.SUBCKT bit1a Cin Cout Init Out add_out clk en fa_in muxA_in muxB_in
+ reg_in
Xmux21 reg_in gnd net_3 Init net_5 mux21
XFA net_3 fa_in Cin Cout add_out FA
Xdffpos net_2 net_1 Out dffpos
Xinv Init net_5 inv
Xmux21_1 muxA_in muxB_in net_1 Init net_4 mux21
Xinv_1 Init net_4 inv
Xand clk en net_2 and
.ENDS	$ bit1a

.GLOBAL gnd vdd
