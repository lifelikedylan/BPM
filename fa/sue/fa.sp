* FILE: fa.sp

* SPICE netlist for "fa" generated by MMI_SUE5.6.37 on Wed Nov 14
*+ 01:41:29 CST 2018.

.SUBCKT fa a b c_in c_out sum
M_1 net_10 net_8 net_3 gnd n W='3*1u' L='0.6*1u'
M_2 net_3 a gnd gnd n W='3*1u' L='0.6*1u'
M_3 net_3 b gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_3 c_in gnd gnd n W='3*1u' L='0.6*1u'
M_5 net_10 c_in net_4 gnd n W='3*1u' L='0.6*1u'
M_6 net_4 b net_11 gnd n W='3*1u' L='0.6*1u'
M_7 net_11 a gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_8 c_in net_7 gnd n W='3*1u' L='0.6*1u'
M_9 net_7 a gnd gnd n W='3*1u' L='0.6*1u'
M_10 net_7 b gnd gnd n W='3*1u' L='0.6*1u'
M_11 net_8 b net_1 gnd n W='3*1u' L='0.6*1u'
M_12 net_1 a gnd gnd n W='3*1u' L='0.6*1u'
M_13 net_5 a vdd vdd p W='6*1u' L='0.6*1u'
M_14 net_5 b vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_5 c_in vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_10 net_8 net_5 vdd p W='6*1u' L='0.6*1u'
M_17 net_6 b net_12 vdd p W='6*1u' L='0.6*1u'
M_18 net_10 c_in net_6 vdd p W='6*1u' L='0.6*1u'
M_19 net_12 a vdd vdd p W='6*1u' L='0.6*1u'
M_20 net_9 a vdd vdd p W='6*1u' L='0.6*1u'
M_21 net_9 b vdd vdd p W='6*1u' L='0.6*1u'
M_22 net_8 c_in net_9 vdd p W='6*1u' L='0.6*1u'
M_23 net_8 b net_2 vdd p W='6*1u' L='0.6*1u'
M_24 net_2 a vdd vdd p W='6*1u' L='0.6*1u'
M_25 sum net_10 gnd gnd n W='3*1u' L='0.6*1u'
M_26 sum net_10 vdd vdd p W='6*1u' L='0.6*1u'
M_27 c_out net_8 gnd gnd n W='3*1u' L='0.6*1u'
M_28 c_out net_8 vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ fa

.GLOBAL gnd vdd
