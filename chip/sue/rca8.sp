* FILE: rca8.sp

* SPICE netlist for "rca8" generated by MMI_SUE5.6.37 on Thu Nov 01
*+ 16:52:23 CDT 2018.

.SUBCKT inv In Out_b
M_1 Out_b In gnd gnd n W='3*1u' L='0.6*1u'
M_2 Out_b In vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ inv

.SUBCKT FA a b c cout sum
M_1 net_9 net_4 net_2 gnd n W='3*1u' L='0.6*1u'
M_2 net_2 a gnd gnd n W='3*1u' L='0.6*1u'
M_3 net_2 b gnd gnd n W='3*1u' L='0.6*1u'
M_4 net_2 c gnd gnd n W='3*1u' L='0.6*1u'
M_5 net_9 c net_8 gnd n W='3*1u' L='0.6*1u'
M_6 net_8 b net_3 gnd n W='3*1u' L='0.6*1u'
M_7 net_3 a gnd gnd n W='3*1u' L='0.6*1u'
M_8 net_4 c net_6 gnd n W='3*1u' L='0.6*1u'
M_9 net_6 a gnd gnd n W='3*1u' L='0.6*1u'
M_10 net_6 b gnd gnd n W='3*1u' L='0.6*1u'
M_11 net_4 b net_12 gnd n W='3*1u' L='0.6*1u'
M_12 net_12 a gnd gnd n W='3*1u' L='0.6*1u'
M_13 net_5 a vdd vdd p W='6*1u' L='0.6*1u'
M_14 net_5 b vdd vdd p W='6*1u' L='0.6*1u'
M_15 net_5 c vdd vdd p W='6*1u' L='0.6*1u'
M_16 net_9 net_4 net_5 vdd p W='6*1u' L='0.6*1u'
M_17 net_7 b net_11 vdd p W='6*1u' L='0.6*1u'
M_18 net_9 c net_7 vdd p W='6*1u' L='0.6*1u'
M_19 net_11 a vdd vdd p W='6*1u' L='0.6*1u'
M_20 net_1 a vdd vdd p W='6*1u' L='0.6*1u'
M_21 net_1 b vdd vdd p W='6*1u' L='0.6*1u'
M_22 net_4 c net_1 vdd p W='6*1u' L='0.6*1u'
M_23 net_4 b net_10 vdd p W='6*1u' L='0.6*1u'
M_24 net_10 a vdd vdd p W='6*1u' L='0.6*1u'
Xinv net_4 cout inv
Xinv_1 net_9 sum inv
.ENDS	$ FA

.SUBCKT rca8 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] B[0] B[1] B[2] B[3]
+ B[4] B[5] B[6] B[7] C_0 Cout Sum[0] Sum[1] Sum[2] Sum[3] Sum[4] Sum[5]
+ Sum[6] Sum[7]
XFA A[0] B[0] C_0 net_1 Sum[0] FA
XFA_1 A[1] B[1] net_1 net_2 Sum[1] FA
XFA_2 A[2] B[2] net_2 net_3 Sum[2] FA
XFA_3 A[3] B[3] net_3 net_7 Sum[3] FA
XFA_4 A[4] B[4] net_7 net_4 Sum[4] FA
XFA_5 A[5] B[5] net_4 net_6 Sum[5] FA
XFA_6 A[6] B[6] net_6 net_5 Sum[6] FA
XFA_7 A[7] B[7] net_5 Cout Sum[7] FA
.ENDS	$ rca8

.GLOBAL gnd vdd
